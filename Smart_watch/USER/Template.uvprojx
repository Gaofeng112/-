# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\Hardware\OLED;..\Hardware\DS1302;..\Hardware\DS18b20;..\Hardware\ADXL345;..\Hardware\XIIC;..\Hardware\MAX30102;..\Hardware\Algorithm;..\SYSTEM\I2C;..\SYSTEM\key;..\Software;..\SYSTEM\time
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/I2C/: I2C.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/key/: key.c
    ../SYSTEM/time/: time.c
  group README
    ../: README.TXT
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group Software
    ../Software/: Watch_display.c Watch_display.h Watch_Management.c Watch_Management.h
  group Hardware
    ../Hardware/OLED/: OLED.c OLED_Data.c OLED.h OLED_Data.h
    ../Hardware/DS1302/: ds1302.c ds1302.h
    ../Hardware/DS18b20/: ds18b20.c ds18b20.h
    ../Hardware/XIIC/: blood.c xiic.c
    ../Hardware/MAX30102/: max30102.c
    ../Hardware/Algorithm/: algorithm.c
    ../Hardware/ADXL345/: ADXL345.c ADXL345.h
